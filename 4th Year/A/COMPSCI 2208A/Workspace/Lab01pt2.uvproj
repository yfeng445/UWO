# Keil uVision project Lab01pt2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI) EBIG
  output: Lab01pt2
  c flags: Optim=1
  group Source Group 1
    ./uVision/: pt2.s
