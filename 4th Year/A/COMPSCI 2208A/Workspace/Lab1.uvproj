# Keil uVision project Lab1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI) EBIG
  output: Lab1
  c flags: Optim=1
  group Source Group 1
    ./: Q2.s
